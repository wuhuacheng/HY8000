# Keil uVision project HY8000.uvprojx, settings and files
target HY8000Cube_RAM (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: HY8000Cube_RAM
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o ./Outbin/HY8000Cube_RAM.bin  ./Outobj/HY8000Cube_RAM.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,VECT_TAB_SRAM
  c misc: --C99
  c include: ../Inc;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_eth.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: ethernetif.c lwip.c main.c stm32f4xx_hal_msp.c freertos.c stm32f4xx_it.c sio.c UdpServerTask.c flashwrite.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c croutine.c event_groups.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: sha1.c arc4.c des.c md4.c md5.c
    ../Middlewares/Third_Party/LwIP/src/api/: netifapi.c netdb.c err.c netbuf.c sockets.c api_msg.c tcpip.c api_lib.c
    ../Middlewares/Third_Party/LwIP/src/core/: udp.c sys.c tcp_in.c tcp_out.c timeouts.c init.c ip.c mem.c def.c raw.c dns.c memp.c inet_chksum.c netif.c stats.c pbuf.c tcp.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: eap.c ccp.c utils.c lcp.c ipv6cp.c ppp.c eui64.c chap_ms.c chap-new.c magic.c mppe.c chap-md5.c pppol2tp.c pppapi.c upap.c multilink.c pppoe.c auth.c ipcp.c demand.c ecp.c vj.c pppcrypt.c fsm.c pppos.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: nd6.c ip6.c ethip6.c ip6_addr.c ip6_frag.c icmp6.c inet6.c mld6.c dhcp6.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: igmp.c autoip.c ip4_frag.c etharp.c dhcp.c ip4.c icmp.c ip4_addr.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
target HY8000Cube_FLS (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: HY8000CUBE_FLS
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o ./Outbin/HY8000CUBE_FLS.bin  ./Outobj/HY8000CUBE_FLS.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: as above
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.1.0
